# Keil uVision project wxt.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MK60DN512xxx10 Freescale
  pack: Keil.Kinetis_K60_DFP.1.5.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: wxt
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\SRC\FWLIB\ADC;..\SRC\FWLIB\CAN;..\SRC\FWLIB\DAC;..\SRC\FWLIB\DELAY;..\SRC\FWLIB\DMA;..\SRC\FWLIB\DMACNT;..\SRC\FWLIB\ENET;..\SRC\FWLIB\FLASH;..\SRC\FWLIB\FTM;..\SRC\FWLIB\GPIO;..\SRC\FWLIB\I2C;..\SRC\FWLIB\LPTM;..\SRC\FWLIB\PDB;..\SRC\FWLIB\PIT;..\SRC\FWLIB\RTC;..\SRC\FWLIB\SD;..\SRC\FWLIB\SPI;..\SRC\FWLIB\SYS;..\SRC\FWLIB\TSI;..\SRC\FWLIB\UART;..\SRC\FWLIB\WDOG;..\SRC\STARTUP;C:\Keil_v5\ARM\Pack\ARM\CMSIS\4.5.0\CMSIS\Include;..\SRC\HARDWARE\SCCB;..\SRC\HARDWARE\Camera;..\SRC\HARDWARE\menu;..\SRC\HARDWARE\OLED;..\SRC\HARDWARE\KEY;..\SRC\USER;..\SRC\HARDWARE\oled_display;..\SRC\HARDWARE\DATA_SEND;..\SRC\HARDWARE\UART_SEND;..\SRC\HARDWARE\DATA_SD;..\SRC\HARDWARE\INI_FLASH;..\PRJ;..\SRC\HARDWARE\LED;..\SRC\HARDWARE\control;..\SRC\HARDWARE\NRF2401;..\SRC\HARDWARE\image_processe;..\SRC\HARDWARE\MOTOR;..\SRC\HARDWARE\ENGINE;..\SRC\HARDWARE\PID;..\SRC\USER;C:\Keil_v5\ARM\Pack\ARM\CMSIS\4.2.0\CMSIS\Include;..\SRC\HARDWARE
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group FWLIB
    ../SRC/FWLIB/CAN/: can.c
    ../SRC/FWLIB/DAC/: dac.c
    ../SRC/FWLIB/DELAY/: delay.c
    ../SRC/FWLIB/DMA/: dma.c
    ../SRC/FWLIB/DMACNT/: dmacnt.c
    ../SRC/FWLIB/ENET/: enet.c
    ../SRC/FWLIB/FLASH/: flash.c
    ../SRC/FWLIB/FTM/: ftm.c
    ../SRC/FWLIB/GPIO/: gpio.c
    ../SRC/FWLIB/I2C/: i2c.c
    ../SRC/FWLIB/LPTM/: lptm.c
    ../SRC/FWLIB/PDB/: pdb.c
    ../SRC/FWLIB/PIT/: pit.c
    ../SRC/FWLIB/RTC/: rtc.c
    ../SRC/FWLIB/SD/: sd.c
    ../SRC/FWLIB/SPI/: spi.c
    ../SRC/FWLIB/SYS/: sys.c
    ../SRC/FWLIB/TSI/: tsi.c
    ../SRC/FWLIB/UART/: uart.c
    ../SRC/FWLIB/WDOG/: wdog.c
    ../SRC/FWLIB/ADC/: adc.c
  group USER
    ../SRC/USER/: main.c isr.c
  group STARTUP
    ../SRC/STARTUP/: system_MK60DZ10.c MK60DZ10.h startup_MK60DZ10.s system_MK60DZ10.h
  group HARDWARE
    ../SRC/HARDWARE/SCCB/: sccb.c
    ../SRC/HARDWARE/Camera/: Camera.c
    ../SRC/HARDWARE/menu/: menu.c
    ../SRC/HARDWARE/OLED/: oled.c
    ../SRC/HARDWARE/oled_display/: oled_display.c
    ../SRC/HARDWARE/DATA_SD/: data_sd.c
    ../SRC/HARDWARE/DATA_SEND/: data_sent.c
    ../SRC/HARDWARE/KEY/: key.c
    ../SRC/HARDWARE/INI_FLASH/: ini_flash.c
    ../SRC/HARDWARE/UART_SEND/: uart_date.c
    ../SRC/HARDWARE/LED/: led.c
    ../SRC/HARDWARE/control/: control.c
    ../SRC/HARDWARE/NRF2401/: nrf2401.c
    ../SRC/HARDWARE/PID/: pid.c
    ../SRC/HARDWARE/ENGINE/: engine.c
    ../SRC/HARDWARE/MOTOR/: motor.c
    ../SRC/HARDWARE/: Handle.c Handle.h shuju.c common.h shuju.h SEEKFREE_MT9V032.c SEEKFREE_MT9V032.h IIC.c IIC.h MK60DN10_cmt.c MK60DN10_cmt.h myadc.c myadc.h SEEKFREE_MPU6050.c SEEKFREE_MPU6050.h MPU6050.c MPU6050.h inv_mpu.c inv_mpu.h inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h Balance.c Balance.h dmpKey.h dmpmap.h S_SPI.c S_SPI.h drv_RF24L01.c drv_RF24L01.h
software components: CMSIS:DSP 1.4.6
